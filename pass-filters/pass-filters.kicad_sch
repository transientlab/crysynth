File: pass-filters/pass-filters.kicad_sch (KiCad schematic)
At the start: 16 parts

Commit message: new kicad
Parts:
- gave numbers to parts that had none: 13
